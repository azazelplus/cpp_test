# Keil uVision project BH-F103.uvprojx, settings and files
target sdio_sdcard (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\fafts\option;..\..\User\fafts;..\..\User\fafts;..\..\User\fafts\option;..\..\User\adc;..\..\User\tim;..\..\User\rtc;..\..\User\delay;..\..\User\usart;..\..\User\led;..\..\User\logger;..\..\User\beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
    ../../User/delay/: delay.c delay.h
  group fafts
    ../../User/fafts/: diskio.c ff.c diskio.h ff.h ffconf.h integer.h
    ../../User/fafts/option/: unicode.c
  group DOC
    ../../Doc/: readme.txt
  group tim
    ../../User/tim/: bsp_tim.c bsp_tim.h
  group RTC
    ../../User/rtc/: bsp_rtc.c bsp_rtc.h
  group adc
    ../../User/adc/: bsp_adc.h bsp_adc.c
  group led
    ../../User/led/: bsp_led.c bsp_led.h
  group usart
    ../../User/usart/: bsp_usart.c bsp_usart.h
  group sd_card
    ../../User/sdio/: bsp_sdio_sdcard.c bsp_sdio_sdcard.h sdio_test.c sdio_test.h
  group logger
    ../../User/logger/: logger.c logger.h
  group beep
    ../../User/beep/: bsp_beep.c bsp_beep.h
