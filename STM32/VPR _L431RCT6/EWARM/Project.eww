<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\VPR _L431RCT6.ewp</path>
  </project>
  <batchBuild />
</workspace>
